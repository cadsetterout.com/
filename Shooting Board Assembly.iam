# Autodesk Inventor assembly: Shooting Board Assembly
## iProperties
Created: 2010-08
Part Number: Shooting Board Assembly
Document SubType Name: Assembly
Designer: Paul Munford
Author: Paul Munford
